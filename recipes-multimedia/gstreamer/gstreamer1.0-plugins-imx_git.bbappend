PACKAGECONFIG[g2d] = ",--disable-g2d,imx-gpu-g2d"
