# latest Vivante libraries splitted g2d in a separeted recipe
PACKAGECONFIG[g2d] = ",--disable-g2d,imx-gpu-g2d"
