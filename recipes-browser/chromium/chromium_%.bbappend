# backporting compile fix from meta-browser master branch
# https://github.com/OSSystems/meta-browser/commit/021a954614d5dc4555e856484c27648757a76b5b
DEPENDS += "gperf-native"
