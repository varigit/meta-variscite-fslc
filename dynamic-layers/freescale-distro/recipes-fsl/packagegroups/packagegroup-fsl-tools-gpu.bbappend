SOC_TOOLS_GPU_append_imxgpu = " \
	imx-gpu-sdk \
	imx-gpu-viv-tools \
"

