PACKAGECONFIG_append = " gstreamer"
