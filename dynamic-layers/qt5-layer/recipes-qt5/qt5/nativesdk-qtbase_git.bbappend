# prevent the overlapping of security permission while building QT5 SDK
DIRFILES = ""

