# integrate Gtreamer optimizations
PACKAGECONFIG_append = " gstreamer"
