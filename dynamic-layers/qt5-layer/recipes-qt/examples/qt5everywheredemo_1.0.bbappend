# add more runtime dependencies
RDEPENDS_${PN}_append = " \
	qtmultimedia-plugins \
	qtmultimedia-qmlplugins \
	qtsvg-plugins \
	qtxmlpatterns-qmlplugins \
"
