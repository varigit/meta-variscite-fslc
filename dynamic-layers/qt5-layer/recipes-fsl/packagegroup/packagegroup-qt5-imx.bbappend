# add common packages also for not X11 builds
QT5_IMAGE_INSTALL_append = " ${QT5_IMAGE_INSTALL_common}"

