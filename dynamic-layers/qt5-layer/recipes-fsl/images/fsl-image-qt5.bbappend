# allow building the toolchian using "-c populate_sdk"
inherit populate_sdk_qt5
