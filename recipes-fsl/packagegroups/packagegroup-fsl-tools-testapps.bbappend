
RDEPENDS_${PN}_remove = "${SOC_TOOLS_TEST}"
