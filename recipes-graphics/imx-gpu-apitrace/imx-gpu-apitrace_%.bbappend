# Migrate source code from codeaurora to github
SRC_URI = "git://github.com/nxp-imx/apitrace-imx.git;protocol=https;branch=imx_7.1"

