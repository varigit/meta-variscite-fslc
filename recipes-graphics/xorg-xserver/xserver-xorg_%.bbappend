OPENGL_PKGCONFIGS = "dri glx glamor dri3 xshmfence"
OPENGL_PKGCONFIGS_remove_mx6 = "glamor"
