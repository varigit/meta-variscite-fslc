SRC_URI = "git://github.com/google/googletest.git;protocol=https;branch=v1.10.x"
