PACKAGECONFIG[python] += "nativesdk-python3-misc nativesdk-python3-json"

 
