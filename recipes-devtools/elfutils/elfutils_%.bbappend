# Use https instead of FTP to fetch source code
SRC_URI = "https://sourceware.org/elfutils/ftp/${PV}/${BP}.tar.bz2"

