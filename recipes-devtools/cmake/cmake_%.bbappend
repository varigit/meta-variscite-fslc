FILES_${PN} += "${datadir}/cmake ${datadir}/aclocal"
FILES_${PN}-dev = ""
