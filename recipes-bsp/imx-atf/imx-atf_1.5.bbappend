FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://imx8mm-atf-uart4.patch"
