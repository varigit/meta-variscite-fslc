SRC_URI = "git://github.com/varigit/imx-atf;protocol=git;branch=${SRCBRANCH}"
SRCBRANCH = "imx_5.4.70_2.3.0_var01"
SRCREV = "e5884084510a2a88101351bed3710860c28c0657"
