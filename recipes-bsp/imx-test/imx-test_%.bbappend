FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-imx-test-mxc_v4l2_overlay-add-autofocus-support.patch \
	    file://0002-imx-test-mxc_v4l2_overlay-fix-stop-focus.patch"
