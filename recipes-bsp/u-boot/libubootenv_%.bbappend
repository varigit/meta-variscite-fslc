FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append = " file://0001-uboot_env-extend-line-length-to-4096.patch"
