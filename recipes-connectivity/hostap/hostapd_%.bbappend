# When using systemd, hostap is disabled by default.
# Do the same when using sysvinit.
INITSCRIPT_PARAMS = "disable"
