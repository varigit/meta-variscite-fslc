FILESEXTRAPATHS_prepend := "${THISDIR}/wpa-supplicant-2.5:"

SRC_URI += "file://key-replay-cve-multiple.patch"

