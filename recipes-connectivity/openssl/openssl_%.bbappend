FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"

PARALLEL_MAKE = ""
