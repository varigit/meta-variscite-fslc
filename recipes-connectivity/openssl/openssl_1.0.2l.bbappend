FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-aes-armv4-bsaes-armv7-sha256-armv4-.pl-make-it-work-.patch"
