SRC_URI = "git://github.com/intel/${BPN};protocol=https;branch=main"
