BRANCH = "main"
SRC_URI_remove = "git://github.com/c-ares/c-ares.git"
SRC_URI_append = "git://github.com/c-ares/c-ares.git;branch=${BRANCH}"
