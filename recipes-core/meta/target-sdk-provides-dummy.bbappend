DUMMYPROVIDES += "\
    perl-module-config \
    perl-module-overloading \
    perl-module-warnings-register \
"
