FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_prepend = "file://issue \
	    file://issue.net \
"
