FILESEXTRAPATHS_prepend_imx6ul-var-dart := "${THISDIR}/files:"
FILESEXTRAPATHS_prepend_imx7-var-som := "${THISDIR}/files:"
