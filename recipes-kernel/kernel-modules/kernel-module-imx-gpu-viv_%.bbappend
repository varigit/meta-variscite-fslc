# Migrate source code from codeaurora to github
KERNEL_SRC = "git://github.com/nxp-imx/linux-imx.git;protocol=https"

